# Keil uVision project CAN_BOX.uvprojx, settings and files
target CAN_BOX (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cc_box +hex
  AfterMake: fromelf.exe --bin --output ./bin/w2_box.bin ./CAN_BOX/cc_box.axf
  AfterMake: .\bin\mcu_tools.exe   ./../Inc/board_info.h  w2_box.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_HAL_DRIVER
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\hardware\inc;..\application\inc;..\event_manage\inc;..\iap_boot\inc;..\device_lib\st25r3916\rfal\Inc;..\device_lib\st25r3916\ST25R3916;..\device_lib\st25r3916\rfal\Src;..\device_lib\st25r3916\demo_test;..\iap_boot\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ../application/src/: command.c
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group application
    ../application/src/: application.c interface.c comm_can.c nfc_interface.c oled_interface.c
  group iap_boot
    ../iap_boot/src/: iap_protocols.c frame_parse.c st_flash.c ex_flash.c
  group event_sig
    ../event_manage/src/: mini_dispatch.c uart_debug.c crc.c def_fifo.c can_def_fifo.c debug_task.c can_fifo.c
  group ST_RFID
    ../device_lib/st25r3916/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_rfst25r3916.c rfal_nfcv.c rfal_nfca.c rfal_nfcb.c rfal_t1t.c rfal_nfc.c rfal_isoDep.c rfal_nfcf.c rfal_st25tb.c rfal_t2t.c
    ../device_lib/st25r3916/ST25R3916/: st25r3916.c st25r3916_com.c st25r3916_irq.c timer.c
    ../device_lib/st25r3916/: analogConfigTbl_NFC06A1.c
  group hardware
    ../hardware/src/: bsp_init.c spi_class.c oled_drv.c rfal_time.c ex_device.c led_beep.c gt32l_drv.c can_drv.c adc_drv.c GT32L32M0180_F103_Keil5.lib st_crc.c rfid3916_class.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group demo_test
    ../device_lib/st25r3916/demo_test/: demo.c demo_ce.c
software components: CMSIS:CORE 5.3.0
